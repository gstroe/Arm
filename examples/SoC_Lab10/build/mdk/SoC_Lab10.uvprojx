# Keil uVision project SoC_Lab10.uvprojx, settings and files
target sram (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.2.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gmac_uip_webserver
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ sram MPU_HAS_NOCACHE_REGION TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include;..\..\..\..\libraries\libuip\source\samv7-specific;..\..\..\..\libraries\libuip\source\uip_1.0;..\..\..\..\libraries\libuip\source\uip_1.0\apps\dhcpc;..\..\..\..\libraries\libuip\source\uip_1.0\lib;..\..\..\..\libraries\libuip\source\uip_1.0\uip;..\..\..\..\libraries\libuip\source\uip_1.0\apps\webserver
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\mdk\sram.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c
  group libchip
    ../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c gmac.c gmacd.c twi.c twid.c
    ../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libboard
    ../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c gmacb_phy.c
  group libuip
    ../../../../libraries/libuip/source/uip_1.0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
    ../../../../libraries/libuip/source/uip_1.0/lib/: memb.c
    ../../../../libraries/libuip/source/samv7-specific/: clock-arch.c gmac_tapdev.c
    ../../../../libraries/libuip/source/uip_1.0/uip/: psock.c timer.c uip-fw.c uip.c uip_arp.c uiplib.c
target flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.2.0
  cpu: as above
  output: gmac_uip_webserver
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash MPU_HAS_NOCACHE_REGION TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_v71\nocache_region\mdk\flash.sct
  link misc: --diag_suppress=L6314
