# Keil uVision project Soc_Lab09.uvprojx, settings and files
target sram (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.2.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: getting-started
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ sram TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_v71\mdk\sram.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c main.h
  group libchip
    ../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c rtt.c
    ../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libboard
    ../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
target flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.2.0
  cpu: as above
  output: getting-started
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_v71\mdk\flash.sct
  link misc: --diag_suppress=L6314
target qspi (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.2.2.0
  cpu: as above
  output: getting-started
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ qspi TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\libraries\libboard\resources_v71\mdk\qspi.sct
  link misc: --diag_suppress=L6314
