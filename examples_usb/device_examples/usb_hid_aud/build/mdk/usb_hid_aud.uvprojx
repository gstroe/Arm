# Keil uVision project usb_hid_aud.uvprojx, settings and files
target sram (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: usb_hid_aud
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ sram TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\..\libraries\libchip;..\..\..\..\..\libraries\libchip\include;..\..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\..\libraries\libboard;..\..\..\..\..\libraries\libboard\include;..\..\..\..\..\libraries\libusb;..\..\..\..\..\libraries\libusb\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\..\libraries\libboard\resources_v71\mdk\sram.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c USBDDriverDescriptors.c
  group libchip
    ../../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c twi.c twid.c ssc.c
    ../../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libboard
    ../../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c wm8904.c
  group libusb
    ../../../../../libraries/libusb/common/core/: USBD_HAL.c USBDescriptors.c USBRequests.c
    ../../../../../libraries/libusb/common/hid/: HIDIdleRequest.c HIDKeypad.c HIDReportRequest.c
    ../../../../../libraries/libusb/common/audio/: AUDFeatureUnitRequest.c AUDGenericRequest.c
    ../../../../../libraries/libusb/device/composite/: AUDDFunction.c HIDAUDDDriver.c
    ../../../../../libraries/libusb/device/audio-speaker/: AUDDSpeakerDriver.c AUDDSpeakerDriver_Callbacks.c
    ../../../../../libraries/libusb/device/audio-speakerphone/: AUDDSpeakerPhoneDriver.c AUDDSpeakerPhoneDriver_Callbacks.c AUDDStream.c
    ../../../../../libraries/libusb/device/hid-transfer/: HIDDFunction.c HIDDTransferDriver.c
    ../../../../../libraries/libusb/device/hid-keyboard/: HIDDKeyboard.c HIDDKeyboardDriver.c HIDDKeyboardCallbacks_LedsChanged.c HIDDKeyboardInputReport.c HIDDKeyboardOutputReport.c
    ../../../../../libraries/libusb/device/hid-mouse/: HIDDMouseDriver.c
    ../../../../../libraries/libusb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
target flash (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: as above
  output: usb_hid_aud
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\..\libraries\libboard\resources_v71\mdk\flash.sct
  link misc: --diag_suppress=L6314
