# Keil uVision project usb_host_msc_hid.uvprojx, settings and files
target sram (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: usb_host_msc_hid
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ sram UHD_NO_SLEEP_MGR ACCESS_MEM_TO_RAM_ENABLED USB_MASS_STORAGE_ENABLE TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\..\libraries\libchip;..\..\..\..\..\libraries\libchip\include;..\..\..\..\..\libraries\libchip\include\samv71;..\..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\..\libraries\libboard;..\..\..\..\..\libraries\libboard\include;..\..\..\..\..\libraries\libfatfs;..\..\..\..\..\libraries\libfatfs\inc;..\..\..\..\..\libraries\libfatfs\src;..\..\conf;..\..\..\..\..\libraries\libusb\host;..\..\..\..\..\libraries\libusb\host\core;..\..\..\..\..\libraries\libusb\host\msc;..\..\..\..\..\libraries\libusb\host\msc\storage\ctrl_access;..\..\..\..\..\libraries\libusb\host\msc\storage\ctrl_access\module_config;..\..\..\..\..\libraries\libusb\host\hid;..\..\..\..\..\libraries\libusb\host\hid\mouse;..\..\..\..\..\libraries\libusb;..\..\..\..\..\libraries\libusb\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\..\libraries\libboard\resources_v71\mdk\sram.sct
  link misc: --diag_suppress=L6314
  group application
    ../../../../../libraries/libboard/resources_v71/mdk/: workaround.s
    ../../: main.c ui.c
  group libchip
    ../../../../../libraries/libchip/source/: exceptions.c mpu.c pio.c pio_it.c pmc.c supc.c tc.c timetick.c uart.c wdt.c xdma_hardware_interface.c xdmac.c xdmad.c
    ../../../../../libraries/libboard/resources_v71/mdk/: retarget.c startup_sam.c
    ../../../../../libraries/libboard/resources_v71/: system_samv71.c
  group libboard
    ../../../../../libraries/libboard/source/: board_lowlevel.c board_memories.c dbg_console.c led.c trace.c
  group libusb
    ../../../../../libraries/libusb/common/core/: USBH_HAL.c
    ../../../../../libraries/libusb/host/core/: USBH.c
    ../../../../../libraries/libusb/host/msc/storage/ctrl_access/: ctrl_access.c
    ../../../../../libraries/libusb/host/msc/: uhi_msc.c uhi_msc_mem.c
    ../../../../../libraries/libusb/host/hid/mouse/: uhi_hid_mouse.c
  group libfatfs
    ../../../../../libraries/libfatfs/src/: fattime_rtc.c ff.c diskio.c
    ../../../../../libraries/libfatfs/src/option/: ccsbcs.c
target flash (ARM-ADS)
  device: ATSAMV71Q21 Atmel
  pack: Keil.SAM-V_DFP.1.0.0
  cpu: as above
  output: usb_host_msc_hid
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAMV71_XULT __SAMV71Q21__ flash UHD_NO_SLEEP_MGR ACCESS_MEM_TO_RAM_ENABLED USB_MASS_STORAGE_ENABLE TRACE_LEVEL=4
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\..\..\..\libraries\libboard\resources_v71\mdk\flash.sct
  link misc: --diag_suppress=L6314
